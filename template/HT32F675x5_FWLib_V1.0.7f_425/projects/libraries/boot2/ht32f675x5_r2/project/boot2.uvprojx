# Keil uVision project boot2.uvprojx, settings and files
target boot2 (ARM-ADS)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: boot2_r2 +hex
  AfterMake: .\boot2.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  AfterMake: fromelf.exe --text -c -o "$L@L.asm"  "!L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MAIN_PROCESSOR
  c include: ..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\..\sources\boards;..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\sources\components\ht32f675x5_r2\crc;..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\sources\projects_source\libraries\boot2\ht32f675x5_r2\boot2;..\config
  asm define: __MAIN_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\boot2.sct
  link misc: --keep=g_stBoot2Header --entry=system_init
  group lib
    ../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.lib
  group components
    ../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
  group boot2
    ../../../../../sources/projects_source/libraries/boot2/ht32f675x5_r2/boot2/: boot2.c
  group main
    ../../../../../sources/projects_source/libraries/boot2/ht32f675x5_r2/main/: main.c
