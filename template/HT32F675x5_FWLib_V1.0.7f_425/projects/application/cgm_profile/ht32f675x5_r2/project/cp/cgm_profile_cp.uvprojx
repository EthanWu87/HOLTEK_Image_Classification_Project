# Keil uVision project cgm_profile_cp.uvprojx, settings and files
target cgm_profile_cp (ARM-ADS)
  device: ARMCM0P Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: cgm_profile_cp +hex
  AfterMake: .\cgm_profile_cp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  AfterMake: ..\..\..\..\..\..\tools\mlog\gen_mlog.bat  cgm_profile_cp  ..\..\..\..\..\..
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CO_PROCESSOR HT32F67595_EVB
  c include: ..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Source;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Config;..\..\..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\rf_init;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_init;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\callback;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\interface;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llp;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_connection_role;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_ctrl_procedure;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_dtm;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_legacy_role;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_priority;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\sec;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\stack\host_stack;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\stack\uecc;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_dis;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_cgms;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_cts;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_gap;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_gatt;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_ota;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_mus;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_services\ble_bas;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ext_flash;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble\interface;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble\llc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble\stack;..\..\..\..\..\..\sources\boards;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\mlog;..\..\..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_timer;..\..\..\..\..\..\sources\components\ht32f675x5_r2\crc;..\..\..\..\..\..\sources\components\ht32f675x5_r2\lpwr_ctrl;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rand;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ota;..\..\..\..\..\..\sources\components\ht32f675x5_r2\calendar;..\..\..\..\..\..\sources\mem_cfg;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\ble\ble_event;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\ble\ble_mem_manage;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\ble\ble_peripheral;..\..\..\..\..\..\sources\projects_source\application\ble_peripheral\ht32f675x5_r2\rtos\ble_task;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\driver;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\components;..\..\..\..\..\..\sources\projects_source\application\cgm_profile\ht32f675x5_r2\app_cgms;..\..\..\..\..\..\sources\components\ht32f675x5_r2\ipc_general;..\..\..\..\..\..\sources\components\ht32f675x5_r2\msg_queue;..\..\config;.\RTE\_cgm_profile_cp
  asm define: __CO_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cgm_profile_cp.sct
  link misc: --entry=Reset_Handler
  group Startup Code
    ../../../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM0plus.s
    ../../../../../../sources/device/ht32f675x5/Source/: system_ARMCM0plus.c
  group config
    ../../config/: app_cfg.h ble_config.h
  group lib
    ../../../../../../libraries/rom/: ht32f675x5_rom_lib_cp_r2.lib
    ../../../../../../libraries/patch/: ht32f675x5_patch_lib_cp_r2.lib
  group rtos
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/rtos/: idle_task.c
  group components
    ../../../../../../sources/components/ht32f675x5_r2/app_timer/: app_timer.c
    ../../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
    ../../../../../../sources/components/ht32f675x5_r2/mlog/: mlog_protocol.c mlog_transport_uart.c
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/components/: linkqueue.c mmu.c ipc.c flash.c
    ../../../../../../sources/components/ht32f675x5_r2/calendar/: calendar.c
    ../../../../../../sources/components/ht32f675x5_r2/ota/: ota.c
    ../../../../../../sources/components/ht32f675x5_r2/msg_queue/: msg_queue.c
    ../../../../../../sources/components/ht32f675x5_r2/ipc_general/: ipc_general_queue.c
  group profile
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_gap/: ble_gap_service.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_dis/: ble_dis.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_gatt/: ble_gatt_service.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_cts/: ble_cts.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_bas/: ble_bas.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_cgms/: cgm_service.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_ota/: ota_service.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_mus/: tt_service.c
  group ble_peripheral
    ../../../../../../sources/ble5.1/ht32f675x5_r2/rf_init/: rf_init.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_init/: ble_init.c ble_controller_init.c ble_host_init.c ble_interface_init.c
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/ble/ble_peripheral/: ble_peripheral.c
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/ble/ble_event/: ble_event.c
  group main
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/main/cp/: main.c app_main.c
  group cgm
    ../../../../../../sources/ble5.1/ht32f675x5_r2/ble_services/ble_cgms/: cgms_meas.c cgms_socp.c cgms_racp.c
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/app_cgms/: cgms_db.c cgms_racp_process.c cgms_utility.c app_cgm_cp.c
  group driver
    ../../../../../../sources/projects_source/application/cgm_profile/ht32f675x5_r2/driver/: uart.c rtc.c dev_info.c spi_master.c
software components: CMSIS:CORE 5.4.0
