# Keil uVision project dtm_cp.uvprojx, settings and files
target dtm_cp (ARM-ADS)
  device: ARMCM0P Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: dtm_cp +hex
  AfterMake: .\dtm_cp.bat "!L" "$KARM\ARMCLANG\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CO_PROCESSOR DTM_PROJECT HT32F67595_EVB
  c include: ..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Include;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Source;..\..\..\..\..\..\third_party\CMSIS\5.7.0\CMSIS\RTOS2\RTX\Config;..\..\..\..\..\..\sources\device\ht32f675x5\Include;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\callback;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\interface;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llp;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_connection_role;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_ctrl_procedure;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_dtm;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_legacy_role;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\llc\llc_priority;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\sec;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\stack\host_stack;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\ble_stack\stack\uecc;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\rf_init;..\..\..\..\..\..\sources\ble5.1\ht32f675x5_r2\dtm_init;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\register;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hw\inc;..\..\..\..\..\..\sources\drivers\ht32f675x5_r2\ht32\hal\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hw\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_hal\inc;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble;..\..\..\..\..\..\sources\patch\ht32f675x5_patch_lib_r2\patch_ble\interface;..\..\..\..\..\..\sources\boards;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\mlog;..\..\..\..\..\..\sources\components\ht32f675x5_r2\err_debug;..\..\..\..\..\..\sources\components\ht32f675x5_r2\app_timer;..\..\..\..\..\..\sources\components\ht32f675x5_r2\hci_app;..\..\..\..\..\..\sources\components\ht32f675x5_r2\crc;..\..\..\..\..\..\sources\components\ht32f675x5_r2\lpwr_ctrl;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rand;..\..\..\..\..\..\sources\components\ht32f675x5_r2\rom_callback;..\..\..\..\..\..\sources\components\ht32f675x5_r2\utility;..\..\..\..\..\..\sources\mem_cfg;..\..\config;.\RTE\_dtm_cp
  asm define: __CO_PROCESSOR
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\dtm_cp.sct
  link misc: --entry=Reset_Handler
  group Startup Code
    ../../../../../../sources/device/ht32f675x5/Source/ARM/: startup_ARMCM0plus.s
    ../../../../../../sources/device/ht32f675x5/Source/: system_ARMCM0plus.c
  group config
    ../../config/: app_cfg.h
  group lib
    ../../../../../../libraries/rom/: ht32f675x5_rom_lib_cp_r2.lib
    ../../../../../../libraries/patch/: ht32f675x5_patch_lib_cp_r2.lib
  group components
    ../../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/mlog/: mlog_protocol.c mlog_transport_uart.c
    ../../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
  group rtos
    ../../../../../../sources/projects_source/authentication/dtm/ht32f675x5_r2/rtos/: idle_task.c
  group hci
    ../../../../../../sources/components/ht32f675x5_r2/hci_app/: hci_cmd.c hci_dtm.c hci_event.c hci_peripheral.c
  group dtm_init
    ../../../../../../sources/ble5.1/ht32f675x5_r2/rf_init/: rf_init.c
    ../../../../../../sources/ble5.1/ht32f675x5_r2/dtm_init/: dtm_init.c
  group main
    ../../../../../../sources/projects_source/authentication/dtm/ht32f675x5_r2/main/cp/: main.c app_main.c
software components: CMSIS:CORE 5.4.0
