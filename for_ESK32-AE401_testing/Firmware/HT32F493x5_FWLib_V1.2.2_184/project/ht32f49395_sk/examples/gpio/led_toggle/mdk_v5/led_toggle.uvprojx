# Keil uVision project led_toggle.uvprojx, settings and files
target led_toggle (6240000::V6.24::ARMCLANG)
  device: HT32F49395_100LQFP Holtek
  pack: Holtek.HT32F493x5_DFP.1.0.6
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_toggle +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HT32F49395_100LQFP,USE_STDPERIPH_DRIVER,USE_HT32F49395_SK
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\ht32f493x5_board;..\..\..\..\..\..\middlewares\i2c_application_library;..\..\..\..\..\..\libraries\drivers\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: ht32f493x5_clock.c ht32f493x5_int.c main.c hm01b0.c
  group bsp
    ../../../../../ht32f493x5_board/: ht32f493x5_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: ht32f493x5_crm.c ht32f493x5_usart.c ht32f493x5_gpio.c ht32f493x5_misc.c ht32f493x5_dma.c ht32f493x5_exint.c ht32f493x5_i2c.c ht32f493x5_spi.c
    ../../../../../../middlewares/i2c_application_library/: i2c_application.c
    D:/GitHub/HOLTEK_Image_Classification_Project/v1.0.0/Data_Collection/Firmware/HT32F493x5_FWLib_V1.2.2_184/libraries/drivers/src/: ht32f493x5_tmr.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_ht32f493x5.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_ht32f493x5.s
  group readme
    ../: readme.txt
